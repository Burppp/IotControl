# IAR project PIDAlgorithm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: ..\Source; ..\..\Common\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Common\STM32F4xx_StdPeriph_Driver\inc; ..\..\Common; ..\..\Common\CMSIS\Include; ..\..\Common\Common Driver; ..\Source\car_imu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PIDAlgorithm.hex
  ILINK.IlinkOutputFile: PIDAlgorithm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Source/: main.c readme.txt
  group Libraries/CMSIS
    ../../Common/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/FWLIB
    ../../Common/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Libraries/STARTUP
    ../../Common/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Source
    ../Source/Arm Algorithm/: arm_algorithm.c arm_algorithm.h
    ../Source/CarMove/: CarMove.c
    ../Source/Debug/: debug_protocol.c
    ../../Common/Common Driver/delay/: delay.c
    ../Source/PID/: direction_pid.c speed_pid.c
    ../Source/Flash/: flash.c
    ../Source/laser/: laser.c laser.h
    ../Source/Motor/: motor.c
    ../Source/MotorSpeed/: motor_speed.c
    ../Source/OLED/: oled.c
    ../Source/PCA9685/: pca9685.c
    ../Source/Servo/: servo.c servo.h
    ../../Common/Common Driver/soft_iic/: soft_iic1.c soft_iic2.c
    ../Source/Wireless/: wireless_protocol.c
    ../../Common/Common Driver/wireless uart/: wireless_usart.c
  group Source/car_imu
    ../Source/car_imu/: acceleration.c compass.c gyro.c gyro_sync.c imu2.c mpu9250.c
    ../Source/car_imu/common/: filter.c maths.c millisecondtimer.c ms_timer.c
