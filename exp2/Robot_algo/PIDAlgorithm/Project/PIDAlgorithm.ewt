<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Libraries</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Common\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>FWLIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Common\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
    </group>
    <group>
      <name>STARTUP</name>
      <file>
        <name>$PROJ_DIR$\..\..\Common\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f40xx.s</name>
      </file>
    </group>
  </group>
  <group>
    <name>Source</name>
    <group>
      <name>car_imu</name>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\acceleration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\compass.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\common\filter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\gyro.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\gyro_sync.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\imu2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\common\maths.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\common\millisecondtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\mpu9250.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\car_imu\common\ms_timer.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Source\Arm Algorithm\arm_algorithm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Arm Algorithm\arm_algorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\CarMove\CarMove.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Debug\debug_protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Common\Common Driver\delay\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PID\direction_pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Flash\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\laser\laser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\laser\laser.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Motor\motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\MotorSpeed\motor_speed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\OLED\oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PCA9685\pca9685.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Servo\servo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Servo\servo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Common\Common Driver\soft_iic\soft_iic1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Common\Common Driver\soft_iic\soft_iic2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PID\speed_pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Wireless\wireless_protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Common\Common Driver\wireless uart\wireless_usart.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\Source\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\readme.txt</name>
  </file>
</project>


